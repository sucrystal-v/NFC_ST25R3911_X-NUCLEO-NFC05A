# IAR project Project.ewp, settings and files
configuration STM32F401RE-Nucleo_PollingTagDetect (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xx; STM32F401xE; USE_HAL_DRIVER; USE_STM32F4XX_NUCLEO; USE_LOGGER=LOGGER_ON; ST25R3911
  ICCARM.CCDiagSuppress: Pa182
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\Drivers\BSP\Components\ST25R3911; ..\..\..\..\..\Middlewares\ST\rfal\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F401RE_NUCLEO_PollingTagDetect.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F401RE_NUCLEO_PollingTagDetectNdef (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F401xx; STM32F401xE; USE_HAL_DRIVER; USE_STM32F4XX_NUCLEO; USE_LOGGER; ST25R3911
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\Drivers\BSP\Components\ST25R3911; ..\..\..\..\..\Middlewares\ST\rfal\Inc; ..\..\..\..\..\Middlewares\ST\ndef\Inc\message; ..\..\..\..\..\Middlewares\ST\ndef\Inc\poller
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: STM32F401RE_NUCLEO_PollingTagDetectNdef.bin
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ST25R3911/: st25r3911.c st25r3911_com.c st25r3911_interrupt.c timer.c
  group Drivers/BSP/STM32F4xx_Nucleo
    ../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Example/EWARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../Src/: demo.c logger.c main.c ndef_demo.c ndef_dump.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group Middlewares/NDEF
    ../../../../../Middlewares/ST/ndef/Src/message/: ndef_message.c ndef_record.c ndef_type_wifi.c ndef_types.c ndef_types_mime.c ndef_types_rtd.c
    ../../../../../Middlewares/ST/ndef/Src/poller/: ndef_poller.c ndef_t2t.c ndef_t3t.c ndef_t4t.c ndef_t5t.c
  group Middlewares/RFAL
    ../../../../../Middlewares/ST/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_rfst25r3911.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
